*v2
*5 nets: VP, A, Y, VN, net1
** sch_path: /home/cass/unic-cass/inverter/buffer.sch
.subckt buffer VP A Y VN
*.PININFO A:I Y:O VP:B VN:B
X1 A net1 VP VN inverter
X2 net1 Y VP VN inverter
.ends

* expanding   symbol:  inverter.sym # of pins=4
** sym_path: /home/cass/unic-cass/inverter/inverter.sym
** sch_path: /home/cass/unic-cass/inverter/inverter.sch
.subckt inverter A Y VP VN
*.PININFO A:I Y:O VP:B VN:B
XM1 Y A VN VN sky130_fd_pr__nfet_01v8 L=0.15 W=1 nf=1 m=1
XM2 Y A VP VP sky130_fd_pr__pfet_01v8 L=0.15 W=1 nf=1 m=1
.ends

.end
