v {xschem version=3.4.4 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {ALib_VCO.sym} 280 -310 0 0 {name=Xvco_1}
C {DLib_UpDownCounter.sym} 600 -350 0 0 {name=x1}
